# Keil uVision project AD5940_BioElec.uvprojx, settings and files
target ADICUP3029 (5060960::V5.06 update 7 (build 960)::.\ARMC5_06_u7)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.3.2.1
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADICUP3029 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHIPSEL_594X, ADI_DEBUG
  c include: ..\..\;..\..\AD5940Lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group AD5940Lib
    ./: ADICUP3029Port.c
    ../../AD5940Lib/: ad5940.c
  group Application
    ./: main.c
    ../: AD5940Main.c BodyImpedance.c Electrocardiograph.c ElectrodermalActivity.c UARTCmd.c
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Global Configuration 2.0.0, Device:Startup 2.0.0
